# Repository joethezombie/Amiga-1000-Rejuvenator

File README.txt:

Amiga 1000 Rejuvenator Re-creation Project
-------------------------------------------------------------------------------------------

Any projects, additions, alterations, derivatives, or improvements based on this
Amiga-1000-Rejuvenator project must be openly shared, including software or PLD coding.
Additionally, on top of the LICENSE specified, the amigalove.com logo and Greg Tibbs name
must always be present in digital releases, and prominently printed on physical
productions.

And with that out of the way...

Thanks to the extreme graciousness of Eric Hill (intric8 at amigalove.com), I had on loan
a Rejuvenator board for the Amiga 1000.  Originally created by Greg Tibbs, this Amiga 1000
hardware upgrade provides up to 2MB Chip Memory, an onboard ROM based kickstart, and an
A2000 style video slot.  Installation requires replacing the A1000's daughterboard with
the Rejuvenator.

This project aims to re-create the original Rejuvenator, and eventually improve on the
design.

Schematics and board artwork are complete, and have been fabricated and tested.  Several
design errors on the original Rejuvenator which required bodge wires and trace cuts to
rectify have been identified and eliminated in the new design.

Again, thanks to the unrelenting determination of Eric over at amigalove.com,
arrangements were made to send the board overseas to Matthias Heinrichs of A1K.org who
successfully solved the last piece of the puzzle and has provided the PLD code.
 
 It has been an abosulute pleasure working with these Amiga community staples!
 
 So what now?  The project will continue with the goal of improving on the original
 design.  Currently, work is being done to provide compatibility with Agnus 8375
 varieties (-10, -11, -16, -17) and replace the DRAM with more available surface mount
 options.

--joethezombie

## KiCad design KiCAD/Amiga-Rejuvenator/Amiga-Rejuvenator.kicad_pcb

Parts:
BT1: 3.6V_Varta; 3.6V Varta
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C25, C26, C27, C28, C29, C31, C33, C34, C35, C36, C38, C39: .1uF; C_Rect_L7.0mm_W2.0mm_P5.00mm
C20, C32, C37: 22uF; C_Rect_L7.0mm_W2.0mm_P5.00mm
C21, C30: 10uF; C_Rect_L7.0mm_W2.0mm_P5.00mm
C23: 47uF; C_Rect_L7.0mm_W2.0mm_P5.00mm
C24: VAR.C; variable_capacitor
CR1, CR2: 1N914; D_DO-35_SOD27_P12.70mm_Horizontal
J1, J18: GND; PinHeader_1x01_P2.54mm_Vertical
J15: 28M; PinHeader_1x01_P2.54mm_Vertical
J17: RMBCLKS; PinHeader_1x01_P2.54mm_Vertical
J19: +12X; PinHeader_1x01_P2.54mm_Vertical
JP100: KICKSTART ENABLE; PinHeader_1x02_P2.54mm_Horizontal
JP101: MEM_CONFIG; PinHeader_1x02_P2.54mm_Vertical
JP102: JUMPERS; PinHeader_1x02_P2.54mm_Vertical
JP103: 2MEG_AGNUS; PinHeader_1x02_P2.54mm_Vertical
JP104: PAL/NTSC; PinHeader_1x02_P2.54mm_Vertical
R1: 47; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal
R2, R3: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal
R4, R5: 3.3K; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal
R6, R7: 33; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R8, R13: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal
R9, R10, R11, R12: 33; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal
R14: 4.7K; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
RP1, RP2, RP3, RP4, RP5: RP; R_Array_SIP10
U1, U21, U22: 74LS245; DIP-20_W7.62mm
U2: 74LS393-U2; DIP-14_W7.62mm
U3, U35: 74F257; DIP-16_W7.62mm
U4, U14, U16, U17: 74LS244-U16,U17; DIP-20_W7.62mm
U5, U15: 74LS373; DIP-20_W7.62mm
U6, U7, U8, U9, U10, U11, U12, U13: V53C104; DIP-20_W7.62mm
U18: 512K-ROM; DIP-40_W15.24mm
U19: 8372-FatAgnus; PLCC-84_THT-Socket
U19B1: 8361-Agnus; DIP-48_W15.24mm_Socket
U20: 8364-Paula; DIP-48_W15.24mm_Socket
U20B1: 8364-Paula; 48pin_blank_socket
U23, U24: RP; DIP-16_W7.62mm
U25: 8362-Denise; DIP-48_W15.24mm_Socket
U25B1: 8362-Denise; 48pin_blank_socket
U26, U34: 74HC245; DIP-20_W7.62mm
U27: OKI6242B; DIP-18_W7.62mm
U28, U29: PAL16L8; DIP-20_W7.62mm
U30, U31: PAL20L8; DIP-24_W7.62mm
U32: 74LS74; DIP-14_W7.62mm
U33: 74LS04; DIP-14_W7.62mm
U36: PALCAS; MOLEX_4455-10_W7.62mm[x2-R]
U37: PALEN; MOLEX_4455-10_W7.62mm[x2-R]
U38: U3I; MOLEX_4455-10_W7.62mm[x2]
U39: U3G; MOLEX_4455-10_W7.62mm[x2]
U40: U2J; MOLEX_4455-8_W7.62mm[x2]
U41: U2I; MOLEX_4455-8_W7.62mm[x2]
X1: X1; MOLEX_4455-2_W7.62mm
X14: X14; MOLEX_4455-4_W7.62mm
X15: X15; MOLEX_4455-6_W7.62mm
X16: VideoSlot 1; PinHeader_2x18_P2.54mm_Vertical
X17: VideoSlot 2; PinHeader_2x18_P2.54mm_Vertical
Y1: Crystal; Crystal_AT310_D3.0mm_L10.0mm_Vertical

Connections (part):
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C25.1, C26.1, C27.1, C28.1, C29.1, C31.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, CR2.1 (K), R4.2, R5.2, R8.2, R13.1, R14.2, RP1.1 (common), RP2.1 (common), RP3.1 (common), RP3.2 (R1), RP4.1 (common), RP4.2 (R1), RP5.1 (common), U1.1 (A->B), U1.20 (VCC), U2.14 (VCC), U3.16 (VCC), U4.20 (VCC), U5.20 (VCC), U6.10 (VCC), U7.10 (VCC), U8.10 (VCC), U9.10 (VCC), U10.10 (VCC), U11.10 (VCC), U12.10 (VCC), U13.10 (VCC), U14.20 (VCC), U15.20 (VCC), U16.20 (VCC), U17.20 (VCC), U18.21 (Vcc), U18.31 (~BYTE), U19.15 (Vcc), U19.36 (n.c.), U19B1.10, U20.27 (Vcc), U20B1.27 (Vcc), U21.1 (A->B), U21.20 (VCC), U22.1 (A->B), U22.20 (VCC), U25.19 (Vcc), U25B1.19 (Vcc), U26.1 (A->B), U26.20 (VCC), U28.20 (VCC)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
+12V: J19.1, R2.2
/7M: U25.35 (7M), U25B1.35 (7M)
/A1: U18.9 (A0), U19.60 (A1), U35.5 (I0b), U41.5
/A2: U3.5 (I0b), U18.8 (A1), U19.61 (A2), U27.4 (A0), U40.5
/A3: U18.7 (A2), U19.62 (A3), U27.5 (A1), U35.2 (I0a), U41.2
/A4: U3.2 (I0a), U18.6 (A3), U19.63 (A4), U27.6 (A2), U40.2
/A5: U3.14 (I0d), U18.5 (A4), U19.64 (A5), U27.7 (A3), U40.14
/A6: U18.4 (A5), U19.65 (A6), U35.14 (I0d), U41.14
/A7: U3.11 (I0c), U18.3 (A6), U19.66 (A7), U40.11
/A8: U18.2 (A7), U19.67 (A8), U35.11 (I0c), U41.11
/A9: U18.40 (A8), U19.68 (A9), U35.6 (I1b), U41.6
/A10: U3.6 (I1b), U18.39 (A9), U19.69 (A10), U40.6
/A11: U18.38 (A10), U19.70 (A11), U35.3 (I1a), U41.3
/A12: U3.3 (I1a), U18.37 (A11), U19.71 (A12), U40.3
/A13: U3.13 (I1d), U18.36 (A12), U19.72 (A13), U40.13
/A14: U18.35 (A13), U19.73 (A14), U35.13 (I1d), U41.13
/A15: U3.10 (I1c), U18.34 (A14), U19.74 (A15), U40.10
/A16: U18.33 (A15), U19.75 (A16), U35.10 (I1c), U41.10
/A17: U18.32 (A16), U19.76 (A17), U31.13 (I13), X1.1
/A18: U18.1 (A17), U19.77 (A18), U29.2 (I2), U31.11 (I11), X1.2
/A19: U19.59 (A19), U28.14 (IO6), U31.9 (I9), U36.3
/A20: U19.35 (A20), U28.15 (IO5), U31.6 (I6), U36.2
/A21: U28.3 (I3), U31.4 (I4), U37.3
/A22: U28.2 (I2), U31.3 (I3), U37.2
/A23: U28.1 (I1), U31.2 (I2), U37.1
/ANAGND: U20.34 (ANAGND), U20B1.34 (ANAGND)
/AUDL: U20.31 (AUDL), U20B1.31 (AUDL)
/AUDR: U20.30 (AUDR), U20B1.30 (AUDR)
/B0: U25.24 (B0), U25B1.24 (B0), U34.6 (A4)
/B1: U25.25 (B1), U25B1.25 (B1), U26.9 (A7)
/B2: U25.26 (B2), U25B1.26 (B2), U26.8 (A6)
/B3: U25.27 (B3), U25B1.27 (B3), U26.7 (A5)
/C4: U5.11 (LE), U15.11 (LE), U33.13 (6A), U35.1 (S), U41.1
/C4b: U3.1 (S), U40.1
/CCK.OA: U19B1.25, U33.5 (3A)
/CCK.P: U20.28 (CCK), U20B1.28 (CCK)
/CCKQ.OA: U19B1.26, U33.3 (2A)
/CCKQ.P: U20.29 (CCKQ), U20B1.29 (CCKQ)
/D0: RP3.3 (R2), U12.18 (IO3), U13.18 (IO3), U14.9 (O0b), U15.13 (D4), U19.14 (D0), U20.10 (D0), U25.7 (D0)
/D1: RP4.3 (R2), U12.19 (IO4), U13.19 (IO4), U14.12 (O3a), U15.8 (D3), U19.13 (D1), U20.9 (D1), U25.6 (D1)
/D2: RP3.4 (R3), U12.2 (IO2), U13.2 (IO2), U14.14 (O2a), U15.7 (D2), U19.12 (D2), U20.7 (D2), U25.5 (D2)
/D3: RP4.4 (R3), U12.1 (IO1), U13.1 (IO1), U14.7 (O1b), U15.14 (D5), U19.11 (D3), U20.6 (D3), U25.4 (D3)
/D4: RP3.5 (R4), U10.18 (IO3), U11.18 (IO3), U14.5 (O2b), U15.17 (D6), U19.10 (D4), U20.5 (D4), U25.3 (D4)
/D5: RP4.5 (R4), U10.19 (IO4), U11.19 (IO4), U14.16 (O1a), U15.4 (D1), U19.9 (D5), U20.4 (D5), U25.2 (D5)
/D6: RP3.6 (R5), U10.2 (IO2), U11.2 (IO2), U14.18 (O0a), U15.3 (D0), U19.8 (D6), U20.3 (D6), U25.1 (D6)
/D7: RP4.6 (R5), U10.1 (IO1), U11.1 (IO1), U14.3 (O3b), U15.18 (D7), U19.7 (D7), U20.2 (D7), U25.48 (D7)
/D8: RP3.7 (R6), U4.9 (O0b), U5.13 (D4), U8.19 (IO4), U9.19 (IO4), U19.6 (D8), U20.1 (D8), U25.47 (D8)
/D9: RP4.7 (R6), U4.12 (O3a), U5.8 (D3), U8.18 (IO3), U9.18 (IO3), U19.5 (D9), U20.48 (D9), U25.46 (D9)
/D10: RP3.8 (R7), U4.14 (O2a), U5.7 (D2), U8.2 (IO2), U9.2 (IO2), U19.4 (D10), U20.47 (D10), U25.45 (D10)
/D11: RP4.8 (R7), U4.7 (O1b), U5.14 (D5), U8.1 (IO1), U9.1 (IO1), U19.3 (D11), U20.46 (D11), U25.44 (D11)
/D12: RP3.9 (R8), U4.5 (O2b), U5.17 (D6), U6.18 (IO3), U7.18 (IO3), U19.2 (D12), U20.45 (D12), U25.43 (D12)
/D13: RP4.9 (R8), U4.16 (O1a), U5.4 (D1), U6.19 (IO4), U7.19 (IO4), U19.1 (D13), U20.44 (D13), U25.42 (D13)
/D14: RP3.10 (R9), U4.18 (O0a), U5.3 (D0), U6.1 (IO1), U7.1 (IO1), U19.84 (D14), U20.43 (D14), U25.41 (D14)
/D15: RP4.10 (R9), U4.3 (O3b), U5.18 (D7), U6.2 (IO2), U7.2 (IO2), U19.83 (D15), U20.42 (D15), U25.40 (D15)
/DMAL: U19.18 (DMAL), U20.12 (DMAL), U20B1.12 (DMAL)
/DRA0: U19.43 (DRA0), U21.2 (A0)
/DRA1: U19.44 (DRA1), U21.3 (A1)
/DRA2: U19.45 (DRA2), U21.4 (A2)
/DRA3: U19.46 (DRA3), U21.5 (A3)
/DRA4: U19.47 (DRA4), U21.6 (A4)
/DRA5: U19.48 (DRA5), U21.9 (A7)
/DRA6: U19.49 (DRA6), U21.8 (A6)
/DRA7: U19.50 (DRA7), U21.7 (A5)
/DRA8: U19.51 (DRA8), U22.9 (A7)
/DRA9: U19.56 (DRA9), U22.4 (A2), U22.6 (A4)
/G0: U25.28 (G0), U25B1.28 (G0), U26.6 (A4)
/G1: U25.29 (G1), U25B1.29 (G1), U26.5 (A3)
/G2: U25.30 (G2), U25B1.30 (G2), U26.4 (A2)
/G3: U25.31 (G3), U25B1.31 (G3), U26.3 (A1)
/LCEN: U29.15 (IO5), U36.15
/M0H: U25.9 (M0H), U25B1.9 (M0H)
/M0V: U25.38 (M0V), U25B1.38 (M0V)
/M1H: U25.8 (M1H), U25B1.8 (M1H)
/M1V: U25.39 (M1V), U25B1.39 (M1V)
/MA0: RP2.5 (R4), U6.6 (A0), U7.6 (A0), U8.6 (A0), U9.6 (A0), U10.6 (A0), U11.6 (A0), U12.6 (A0), U13.6 (A0), U23.16 (R1.2)
/MA1: RP2.4 (R3), U6.7 (A1), U7.7 (A1), U8.7 (A1), U9.7 (A1), U10.7 (A1), U11.7 (A1), U12.7 (A1), U13.7 (A1), U23.15 (R2.2)
/MA2: RP2.3 (R2), U6.8 (A2), U7.8 (A2), U8.8 (A2), U9.8 (A2), U10.8 (A2), U11.8 (A2), U12.8 (A2), U13.8 (A2), U23.14 (R3.2)
/MA3: RP2.2 (R1), U6.9 (A3), U7.9 (A3), U8.9 (A3), U9.9 (A3), U10.9 (A3), U11.9 (A3), U12.9 (A3), U13.9 (A3), U23.13 (R4.2)
/MA4: RP1.2 (R1), U6.11 (A4), U7.11 (A4), U8.11 (A4), U9.11 (A4), U10.11 (A4), U11.11 (A4), U12.11 (A4), U13.11 (A4), U23.12 (R5.2)
/MA5: RP1.3 (R2), U6.12 (A5), U7.12 (A5), U8.12 (A5), U9.12 (A5), U10.12 (A5), U11.12 (A5), U12.12 (A5), U13.12 (A5), U23.9 (R8.2)
/MA6: RP1.4 (R3), U6.13 (A6), U7.13 (A6), U8.13 (A6), U9.13 (A6), U10.13 (A6), U11.13 (A6), U12.13 (A6), U13.13 (A6), U23.10 (R7.2)
/MA7: RP1.5 (R4), U6.14 (A7), U7.14 (A7), U8.14 (A7), U9.14 (A7), U10.14 (A7), U11.14 (A7), U12.14 (A7), U13.14 (A7), U23.11 (R6.2)
/MA8: RP1.6 (R5), U6.15 (A8), U7.15 (A8), U8.15 (A8), U9.15 (A8), U10.15 (A8), U11.15 (A8), U12.15 (A8), U13.15 (A8), U24.9 (R8.2)
/MA9: JP103.1, RP2.6 (R5), U6.5 (A9), U7.5 (A9), U8.5 (A9), U9.5 (A9), U10.5 (A9), U11.5 (A9), U12.5 (A9), U13.5 (A9)
/MCFG1: JP101.2, RP5.2 (R1), U31.23 (I23)
/MCFG2: JP102.2, RP5.3 (R2), U31.1 (I1)
/OVL: U28.6 (I6), U30.7 (I7), U31.7 (I7), U37.6
/PD0: U14.11 (I0b), U15.12 (O4), U16.11 (I0b), U18.13 (Q0), U27.14 (D0), U38.11
/PD1: U14.8 (I3a), U15.9 (O3), U16.8 (I3a), U18.15 (Q1), U27.13 (D1), U38.8
/PD2: U14.6 (I2a), U15.6 (O2), U16.6 (I2a), U18.17 (Q2), U27.12 (D2), U38.6
/PD3: U14.13 (I1b), U15.15 (O5), U16.13 (I1b), U18.19 (Q3), U27.11 (D3), U38.13
/PD4: U14.15 (I2b), U15.16 (O6), U16.15 (I2b), U18.22 (Q4), U38.15
/PD5: U14.4 (I1a), U15.5 (O1), U16.4 (I1a), U18.24 (Q5), U38.4
/PD6: U14.2 (I0a), U15.2 (O0), U16.2 (I0a), U18.26 (Q6), U38.2
/PD7: U14.17 (I3b), U15.19 (O7), U16.17 (I3b), U18.28 (Q7), U38.17
/PD8: U4.11 (I0b), U5.12 (O4), U17.17 (I3b), U18.14 (Q8), U39.17
/PD9: U4.8 (I3a), U5.9 (O3), U17.2 (I0a), U18.16 (Q9), U39.2
/PD10: U4.6 (I2a), U5.6 (O2), U17.4 (I1a), U18.18 (Q10), U39.4
/PD11: U4.13 (I1b), U5.15 (O5), U17.15 (I2b), U18.20 (Q11), U39.15
/PD12: U4.15 (I2b), U5.16 (O6), U17.13 (I1b), U18.23 (Q12), U39.13
/PD13: U4.4 (I1a), U5.5 (O1), U17.6 (I2a), U18.25 (Q13), U39.6
/PD14: U4.2 (I0a), U5.2 (O0), U17.8 (I3a), U18.27 (Q14), U39.8
/PD15: U4.17 (I3b), U5.19 (O7), U17.11 (I0b), U18.29 (Q15/A-1), U39.11
/POT0X: U20.32 (POT0X), U20B1.32 (POT0X)
/POT0Y: U20.33 (POT0Y), U20B1.33 (POT0Y)
/POT1X: U20.35 (POT1X), U20B1.35 (POT1X)
/POT1Y: U20.36 (POT1Y), U20B1.36 (POT1Y)
/R0: U25.20 (R0), U25B1.20 (R0), U34.2 (A0)
/R1: U25.21 (R1), U25B1.21 (R1), U34.3 (A1)
/R2: U25.22 (R2), U25B1.22 (R2), U34.4 (A2)
/R3: U25.23 (R3), U25B1.23 (R3), U34.5 (A3)
/RA0: U1.15 (B3), U35.7 (Yb), U41.7
/RA1: U1.12 (B6), U3.7 (Yb), U40.7
/RA2: U1.16 (B2), U35.4 (Ya), U41.4
/RA3: U1.11 (B7), U3.4 (Ya), U40.4
/RA4: U1.13 (B5), U3.12 (Yd), U40.12
/RA5: U1.18 (B0), U35.12 (Yd), U41.12
/RA6: U1.14 (B4), U3.9 (Yc), U40.9
/RA7: U1.17 (B1), U35.9 (Yc), U41.9
/REJ.A0: U1.5 (A3), U2.3 (1QA)
/REJ.A1: U1.8 (A6), U2.9 (2QC)
/REJ.A2: U1.4 (A2), U2.4 (1QB)
/REJ.A3: U1.9 (A7), U2.8 (2QD)
/REJ.A4: U1.7 (A5), U2.10 (2QB)
/REJ.A5: U1.2 (A0), U2.6 (1QD), U2.13 (2A)
/REJ.A6: U1.6 (A4), U2.11 (2QA)
/REJ.A7: U1.3 (A1), U2.5 (1QC)
/REJKICK: RP5.4 (R3), U29.7 (I7), U31.21 (IO21), U32.5 (1Q)
/RGA1: U19.33 (RGA1), U20.26 (RGA1), U25.17 (RGA1)
/RGA2: U19.32 (RGA2), U20.25 (RGA2), U25.16 (RGA2)
/RGA3: U19.31 (RGA3), U20.24 (RGA3), U25.15 (RGA3)
/RGA4: U19.30 (RGA4), U20.23 (RGA4), U25.14 (RGA4)
/RGA5: U19.29 (RGA5), U20.22 (RGA5), U25.13 (RGA5)
/RGA6: U19.28 (RGA6), U20.21 (RGA6), U25.12 (RGA6)
/RGA7: U19.27 (RGA7), U20.20 (RGA7), U25.11 (RGA7)
/RGA8: U19.26 (RGA8), U20.19 (RGA8), U25.10 (RGA8)
/RxD: U20.41 (RxD), U20B1.41 (RxD)
/TxD: U20.40 (TxD), U20B1.40 (TxD)
/UCEN: U29.16 (IO4), U36.16
/X.B0: U34.14 (B4), X16.23
/X.B1: U26.11 (B7), X17.10
/X.B2: U26.12 (B6), X17.11
/X.B3: U26.13 (B5), X16.25
/X.G0: U26.14 (B4), X17.6
/X.G1: U26.15 (B3), X17.7
/X.G2: U26.16 (B2), X17.8
/X.G3: U26.17 (B1), X16.27
/X.R0: U34.18 (B0), X17.2
/X.R1: U34.17 (B1), X17.3
/X.R2: U34.16 (B2), X17.4
/X.R3: U34.15 (B3), X16.29
/X.~BURST: R12.2, U34.13 (B5)
/X.~ZD: U26.18 (B0), X16.30
/XD0: U16.9 (O0b), U38.9
/XD1: U16.12 (O3a), U38.12
/XD2: U16.14 (O2a), U38.14
/XD3: U16.7 (O1b), U38.7
/XD4: U16.5 (O2b), U38.5
/XD5: U16.16 (O1a), U38.16
/XD6: U16.18 (O0a), U38.18
/XD7: U16.3 (O3b), U38.3
/XD8: U17.3 (O3b), U39.3
/XD9: U17.18 (O0a), U39.18
/XD10: U17.16 (O1a), U39.16
/XD11: U17.5 (O2b), U39.5
/XD12: U17.7 (O1b), U39.7
/XD13: U17.14 (O2a), U39.14
/XD14: U17.12 (O3a), U39.12
/XD15: U17.9 (O0b), U39.9
/XRDY: U28.8 (I8), U37.8
/_REJ1: U28.5 (I5), U30.18 (IO18)
/_REJ2: U30.3 (I3), U31.15 (IO15)
/_REJ3: U28.19 (IO1), U29.1 (I1)
/iC4: U33.12 (6Y), X16.19
/iCCK.OA: R10.2, U33.6 (3Y)
/iCCKQ.OA: R11.2, U33.4 (2Y)
/i~CDAC: U33.2 (1Y), X17.15
/~AS: U19.24 (~AS), U28.4 (I4), U29.11 (I10), U30.5 (I5), U31.5 (I5), U37.4
/~BLIT: U19.20 (~BLIT), U30.13 (I13)
/~BLS: U19.19 (~BLISS), U28.18 (IO2), U37.18
/~BURST: U25.18 (~BURST), U25B1.18 (~BURST), U34.7 (A5)
/~C1: U28.11 (I10), U29.9 (I9), U30.10 (I10), U31.10 (I10), U36.13, U37.11
/~C3: U28.9 (I9), U30.11 (I11), U31.14 (I14), U37.9
/~CAS: U25.36 (~CAS), U25B1.36 (~CAS)
/~CASL: U19.54 (~CASL), U22.7 (A5)
/~CASLX: RP1.8 (R7), U10.17 (~CAS), U11.17 (~CAS), U12.17 (~CAS), U13.17 (~CAS), U24.11 (R6.2)
/~CASU: U19.55 (~CASU), U22.8 (A6)
/~CASUX: RP1.7 (R6), U6.17 (~CAS), U7.17 (~CAS), U8.17 (~CAS), U9.17 (~CAS), U24.10 (R7.2)
/~CBL: U25.32 (~CBL), U33.8 (4Y), X16.14
/~CDAC: R6.2, U25.34 (~CDAC), U33.1 (1A)
/~CDR: U29.17 (I03), U36.17
/~CDRREJ: U5.1 (OE), U15.1 (OE), U30.16 (IO16)
/~CDW: U29.18 (IO2), U36.18
/~CDWREJ: U4.1 (OEa), U4.19 (OEb), U14.1 (OEa), U14.19 (OEb), U30.17 (IO17)
/~CDW~b: U16.1 (OEa), U38.1
/~CDW~c: U16.19 (OEb), U38.19
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
Notes on the sheet:
SOCKET
Mainboard Interface
PLD
Memory Expansion
Custom Chipset
Video Slot
DECOUPLING
REALTIME CLOCK
REJ 74LS244
REJ 74LS373
MB 74LS244
~ROME
~RGAE
~DAE
~PALOPE
~RE
~DBR
257 HEADER
244 HEADER
HEADER
_CLKE

Board: 4 copper layers, 241.8 x 174.8 mm, 120 parts (0 on the bottom side), 278 nets.
